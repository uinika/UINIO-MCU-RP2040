# Repository uinika/UINIO-MCU-RP2040

File README.md:

# UINIO-MCU-RP2040 核心板

[**UINIO-MCU-RP2040**](https://gitee.com/uinika/UINIO-MCU-RP2040) 是一款基于树莓派 RP2040 微控制器的核心板，该主控芯片采用 **ARM Cortex-M0+** 双核心，运行频率高达 `133MHz`，片上内置有 `264KB` 容量的 **SRAM** 内存，并且能够外接高达 `16MB` 容量的片外 **Flash** 闪存（通过专用的 QSPI 总线进行连接），并且还集成有 DMA 控制器，以及 30 个 **GPIO** 引脚（其中 4 个可用作模拟输入）。除此之外，片上还拥有 2 个 **UART** 控制器、2 个 **SPI** 控制器、2 个 **I²C** 控制器，以及 16 个 **PWM** 通道。同时还支持 **USB 1.1** 设备和主机模式，以及 USB 大容量存储启动模式和拖放式编程。

## 设计概要

1. Flash 存储芯片采用了更加小巧的 `WSON8` 封装；
2. 添加 `SOD123` 封装的**肖特基势垒二极管**，用于防止正负级错误的反接；
3. 预留有 `2mm` 的固定螺丝孔，便于安装至 3D 打印外壳，或者搭建成套的产品原型；
4. 添加了用于全局异步复位的 **RESET** 按钮（低电平有效），便于在上电状态进行复位操作以及更新固件；
5. 引出了官方 Pico 开发板没有的 `GPIO23` 和 `GPIO24` 两个引脚资源，并且在 `GPIO25` 引脚采用了与 Pico 相同的测试用 LED 发光二极管；
6. 由于 ADC 引脚内部集成有连接至 `IOVDD`（`3.3V`）的反向二极管，所以采用了 FET 场效应管 **DMG1012T** 防止在 RP2040 没有上电的时候，这些引脚上施加的电压通过 `ADC3` 引脚泄露到 `3.3V` 电源网络；

> **注意**： 核心板引脚顺序并不完全兼容官方的 **Raspberry Pi Pico** 开发板。

## 固件更新

**UINIO-MCU-RP2040** 的固件更新操作流程如下面步骤所示：

1. 按住 **BOOT** 按键不放，将核心板的 Type-C 接口连接到电脑的；
2. 等待 1 秒钟之后，松开 **BOOT** 按键，此时计算机会自动将 **UINIO-MCU-RP2040** 识别为可移动磁盘；
3. 将等待下载的固件拖动或者复制到该可移动磁盘当中，此时 **RP2040** 主控会自动重启并且加载固件；

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 UINIO-MCU-RP2040 开源项目提供了如下一系列技术参考资料：

- [《UINIO-DAPLink 核心板原理图》](http://uinio.com/my/works/UINIO-MCU-RP2040/UINIO-MCU-RP2040-Schematic.pdf)
- [《交互式 BOM 物料清单与 PCB 版图在线预览》](http://uinio.com/my/works/UINIO-MCU-RP2040/UINIO-MCU-RP2040-BOM.html)
- [《基于树莓派 UINIO-MCU-RP2040 核心板制作逻辑分析仪》](http://uinio.com/Project/UINIO-MCU-RP2040/)

## KiCad design UINIO-MCU-RP2040.kicad_pcb

Parts:
C1, C2: 1uF; C_0603_1608Metric
C3: 0.01uF; C_0603_1608Metric
C4, C5: 12pF; C_0402_1005Metric
C6, C7, C8, C10, C11, C17: 0.1uF; C_0402_1005Metric
C9, C12, C15: 2.2uF; C_0402_1005Metric
C16: 1nF; C_0402_1005Metric
D1: 1N4007; Nexperia_CFP3_SOD-123W
D2: LED_Red; LED_0603_1608Metric
D3: LED_Blue; LED_0603_1608Metric
D4, D5: LESD5D5.0CT1G; D_SOD-523
F1: 60V 1A; Fuse_1206_3216Metric
J1, J2: Conn_01x20_Pin; PinHeader_1x20_P2.54mm_Vertical
J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
Q1: DMG1012T; SOT-523
R1: 512R; R_0603_1608Metric
R2, R3: 5.1K; R_0603_1608Metric
R4: 2K; R_0603_1608Metric
R5: 1.5K; R_0402_1005Metric
R6, R7: 27R; R_0402_1005Metric
R8: 470R; R_0402_1005Metric
R9: 100K; R_0402_1005Metric
R10: 200K; R_0402_1005Metric
R11: 1R; R_0402_1005Metric
R12: 200R; R_0603_1608Metric
R13: 1K; R_0402_1005Metric
R14: 10K; R_0402_1005Metric
SW1: ~{RESET}; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.7
SW2: ~{USB_BOOT}; KEY-SMD_4P-L4.2-W3.4-P2.15-LS4.7
U1: SGM2019-3.3YN5G; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U2: SPI-25-Flash-WSON8; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
U3: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
USB1: USB_Type_C_16Pin; USB-C-SMD_TYPEC-304J-BCP16
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C7.1, C8.1, C9.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
/ADC_AVDD: C15.1, R11.2, U3.43 (ADC_AVDD)
/ADC_VREF: J2.5, R11.1, R12.2
/Boot_Select: R5.2, R13.1, U2.1 (~CS), U3.56 (QSPI_SS)
/GPIO0: J1.3, U3.2 (GPIO0)
/GPIO1: J1.4, U3.3 (GPIO1)
/GPIO2: J1.5, U3.4 (GPIO2)
/GPIO3: J1.6, U3.5 (GPIO3)
/GPIO4: J1.7, U3.6 (GPIO4)
/GPIO5: J1.8, U3.7 (GPIO5)
/GPIO6: J1.9, U3.8 (GPIO6)
/GPIO7: J1.10, U3.9 (GPIO7)
/GPIO8: J1.11, U3.11 (GPIO8)
/GPIO9: J1.12, U3.12 (GPIO9)
/GPIO10: J1.13, U3.13 (GPIO10)
/GPIO11: J1.14, U3.14 (GPIO11)
/GPIO12: J1.15, U3.15 (GPIO12)
/GPIO13: J1.16, U3.16 (GPIO13)
/GPIO14: J1.17, U3.17 (GPIO14)
/GPIO15: J1.18, U3.18 (GPIO15)
/GPIO16: J2.17, U3.27 (GPIO16)
/GPIO17: J2.16, U3.28 (GPIO17)
/GPIO18: J2.15, U3.29 (GPIO18)
/GPIO19: J2.14, U3.30 (GPIO19)
/GPIO20: J2.13, U3.31 (GPIO20)
/GPIO21: J2.12, U3.32 (GPIO21)
/GPIO22: J2.11, U3.34 (GPIO22)
/GPIO23: J2.10, U3.35 (GPIO23)
/GPIO24: J2.9, U3.36 (GPIO24)
/GPIO25: R8.2, U3.37 (GPIO25)
/GPIO26_ADC0: J2.8, U3.38 (GPIO26_ADC0)
/GPIO27_ADC1: J2.7, U3.39 (GPIO27_ADC1)
/GPIO28_ADC2: J2.6, U3.40 (GPIO28_ADC2)
/GPIO29_ADC3: Q1.2 (S), U3.41 (GPIO29_ADC3)
/LDO_EN: J2.4, R1.2, U1.3 (EN)
/QSPI_SCLK: U2.6 (CLK), U3.52 (QSPI_SCLK)
/QSPI_SD0: U2.5 (DI(IO0)), U3.53 (QSPI_SD0)
/QSPI_SD1: U2.2 (DO(IO1)), U3.55 (QSPI_SD1)
/QSPI_SD2: U2.3 (IO2), U3.54 (QSPI_SD2)
/QSPI_SD3: U2.7 (IO3), U3.51 (QSPI_SD3)
/RUN: J2.18, R14.2, SW1.1, SW1.2, U3.26 (RUN)
/USB_5V: C1.2, J1.2, R1.1, R10.2, U1.1 (IN), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/USB_Data+: R6.1, U3.47 (USB_DP)
/USB_Data-: R7.1, U3.46 (USB_DM)
/VDD_3.3V: C6.1, C10.1, C11.1, C12.1, C17.1, D1.1 (K), F1.1, J1.19, J2.2, J2.19, J3.1, Q1.1 (G), R4.2, R5.1, R12.1, R14.1, U2.8 (VCC), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, C16.1, C17.2, D1.2 (A), D2.1 (K), D3.1 (K), D4.1 (A1), D5.1 (A1), J1.1, J1.20, J2.1, J2.3, J2.20, J3.4, R2.2, R3.2, R9.1, SW1.3, SW1.4, SW2.3, SW2.4, U1.2 (GND), U2.4 (GND), U2.9 (EP), U3.19 (TESTEN), U3.57 (GND), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: C4.2, Y1.2
unnamed: C5.2, Y1.4
unnamed: D2.2 (A), R4.1
unnamed: D3.2 (A), R8.1
unnamed: D4.2 (A2), R7.2, USB1.A7 (DN1), USB1.B7 (DN2)
unnamed: D5.2 (A2), R6.2, USB1.A6 (DP1), USB1.B6 (DP2)
unnamed: J3.2, U3.25 (SWD)
unnamed: J3.3, U3.24 (SWCLK)
unnamed: C16.2, Q1.3 (D), R9.2, R10.1
unnamed: R13.2, SW2.1, SW2.2
unnamed: C3.2, U1.4 (FB)
unnamed: C2.2, F1.2, U1.5 (OUT)
unnamed: U3.20 (XIN), Y1.3
unnamed: U3.21 (XOUT), Y1.1
unnamed: R2.1, USB1.A5 (CC1)
unnamed: R3.1, USB1.B5 (CC2)

Notes on the sheet:
圣邦微 3.3V 线性稳压电路
QSPI 总线 Flash 存储器
BOOT 与 RESET 按键
20 × 2 杜邦针
USB Type-C 接口电路
树莓派 RP2040 微控制器最小系统

Board: 2 copper layers, 62.0 x 27.9 mm, 50 parts (0 on the bottom side), 62 nets.

Other parts of the board:
HOLE**: Hole-2mm
HOLE**#2, HOLE**#3, HOLE**#4: Hole-2mm

## Commit log

2024-01-15 Initialization project.
2024-01-18 Update reference for the RP2040 chip.
2024-01-19 Add some reference schematics.
2024-01-21 Part of the schematic diagram is drawn.
2024-01-22 Complete the schematic drawing.
2024-01-22 PCB preliminary layout.
2024-01-26 Finish PCB layout.
2024-01-27 Complete PCB wiring.
2024-01-27 Reorganize the documents.
2024-01-30 Release UINIO-MCU-RP2040 version 1.0.0.
2024-01-31 Update README.md.
2024-02-02 Update schematic.
2024-02-02 Adjust circuit parameter values.
2024-02-04 Release UINIO-MCU-RP2040 version 2.0.0.
2024-03-10 Update PCB.
2024-04-13 Release UINIO-MCU-RP2040 version 2.2.0.
2024-09-04 Release UINIO-MCU-RP2040 version 3.0.0.
2024-11-01 Release UINIO-MCU-RP2040 version 3.2.0.
2024-11-26 Release UINIO-MCU-RP2040 version 5.0.0.
